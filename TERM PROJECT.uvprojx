# Keil uVision project TERM PROJECT.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TERM PROJECT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: ..\..\..\semester 7\CSE_211 Introduction to Embedded Systems\tivaware_c_series_2_1_4_178\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: main.c bitwise_operation.h DIO.c DIO.h tm4c123gh6pm.h types.h motor_driver.c motor_driver.h
  group library
    ../../../semester 7/CSE_211 Introduction to Embedded Systems/tivaware_c_series_2_1_4_178/driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
